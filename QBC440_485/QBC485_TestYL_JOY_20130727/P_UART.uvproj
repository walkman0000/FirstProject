# Keil uVision project P_UART.uvproj, settings and files
target Test_YLJOY_101284C (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: P_UART
  c flags: Optim=1 wLevel=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Source Group 1
    ./: LPC2400.s main.c time.c uart0.c uart1.c uart2.c uart3.c IOcontrol.c KeyDataToSend.c
